# IAR project Cornell.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TI_DRIVERS_UART_DMA; SL_PLATFORM_MULTI_THREADED; NDEBUG; ENABLE_LPDS
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; -I$PROJ_DIR$; -I$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/posix/iar; -I$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/net/http; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: System\HeaderFiles; JSONParser\include; HttpParser\include; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Cornell.bin
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  postbuild: ielftool.exe --bin --verbose "Debug/Exe/$PROJ_FNAME$.out" "Debug/Exe/$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: Cornell.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC3220SF_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4/grlib.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4/spiffs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4/fatfs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/devices/cc32xx/driverlib/iar/Release/driverlib.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/net/wifi/iar/rtos/simplelink.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/net/http/lib/iar/m4/httpclient_debug.a; --silent; --cpu=Cortex-M4; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; -I$PROJ_DIR$; -I$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/posix/iar; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: System\HeaderFiles; HttpParser\include; JSONParser\include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: CornellRelease.bin
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4/grlib.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4/spiffs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4/fatfs.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc32xx.arm4; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/devices/cc32xx/driverlib/iar/Release/driverlib.a; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/net/wifi/iar/rtos/simplelink.a; --silent; --cpu=Cortex-M4; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  group Configuration files
    ./: Cornell.cfg Cornell_CC3220SF_LAUNCHXL_TIRTOS.icf
  group HttpParser/include
    HttpParser/include/: http_parser.h picohttpparser.h
  group HttpParser/source
    HttpParser/source/: http_parser.c picohttpparser.c
  group JSonParser/include
    JSONParser/include/: jsmn.h
  group JSonParser/source
    JSONParser/source/: jsmn.c
  group Platform/HeaderFiles
    ./: Board.h CC3220SF_LAUNCHXL.h
    System/HeaderFiles/: platform.h
  group Platform/SourceFiles
    ./: CC3220SF_LAUNCHXL.c platform.c
  group System/HeaderFiles
    System/HeaderFiles/: ADC_Channel.h EventQ.h ExtCommunication.h FirmwareUpload.h GPS.h InstrumentInfo.h ManufacturingTestCodes.h PowerManagement.h SlHttpCli.h SPI_Comm.h SysDef.h SysTask.h TimerTask.h WatchDog.h WifiHTTPClient.h WifiTask.h
  group System/SourceFiles
    System/SourceFiles/: ADC_Channel.c EventQ.c ExtCommunication.c FirmwareUpload.c GPS.c main.c ManufacturingTestCodes.c PowerCC32XX_tirtos.c PowerManagement.c SlHttpCli.c SPI_Comm.c SysTask.c TimerTask.c WatchDog.c WifiHTTPClient.c WifiTask.c
    $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/drivers/: UART.c
